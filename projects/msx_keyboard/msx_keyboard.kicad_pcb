# Repository hra1129/KiCad_parts_for_MSX

## KiCad design projects/msx_keyboard/msx_keyboard.kicad_pcb

Parts:
C1: C; C_Disc_D3.0mm_W1.6mm_P2.50mm
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11: 1N4001; D_DO-41_SOD81_P10.16mm_Horizontal
D12: CAPS_LED; LED_D5.0mm
D13: KANA_LED; LED_D5.0mm
J1: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
J2: Conn_01x08_Pin; PinHeader_1x08_P2.54mm_Vertical
J3, J4: Conn_01x01_Pin; PinSocket_1x01_P2.54mm_Vertical
J5: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW_0, SW_1, SW_2, SW_3, SW_4, SW_5, SW_6, SW_7, SW_8, SW_9: SW_Push_45deg; CherryMX_1U
SW_A1: SW_Push_45deg; CherryMX_1U
SW_ASTA1: SW_Push_45deg; CherryMX_1U
SW_AT1: SW_Push_45deg; CherryMX_1U
SW_B1: SW_Push_45deg; CherryMX_1U
SW_BS1: SW_Push_45deg; CherryMX_1U
SW_C1: SW_Push_45deg; CherryMX_1U
SW_CAPS1: SW_Push_45deg; CherryMX_1U
SW_CLS1: SW_Push_45deg; CherryMX_1.5U
SW_CTRL1: SW_Push_45deg; CherryMX_2U
SW_D1: SW_Push_45deg; CherryMX_1U
SW_DEL1: SW_Push_45deg; CherryMX_1.5U
SW_DOWN1: SW_Push_45deg; CherryMX_1U
SW_E1: SW_Push_45deg; CherryMX_1U
SW_ESC1: SW_Push_45deg; CherryMX_1U
SW_F1, SW_F2, SW_F3, SW_F4, SW_F5: SW_Push_45deg; CherryMX_1.5U
SW_F6: SW_Push_45deg; CherryMX_1U
SW_G1: SW_Push_45deg; CherryMX_1U
SW_GRP1: SW_Push_45deg; CherryMX_1U
SW_GT1: SW_Push_45deg; CherryMX_1U
SW_H1: SW_Push_45deg; CherryMX_1U
SW_HAT1: SW_Push_45deg; CherryMX_1U
SW_I1: SW_Push_45deg; CherryMX_1U
SW_INS1: SW_Push_45deg; CherryMX_1.5U
SW_J1: SW_Push_45deg; CherryMX_1U
SW_K1: SW_Push_45deg; CherryMX_1U
SW_KANA1: SW_Push_45deg; CherryMX_1U
SW_L1: SW_Push_45deg; CherryMX_1U
SW_LBRAC1: SW_Push_45deg; CherryMX_1U
SW_LEFT1: SW_Push_45deg; CherryMX_1U
SW_LT1: SW_Push_45deg; CherryMX_1U
SW_M1: SW_Push_45deg; CherryMX_1U
SW_MINUS1: SW_Push_45deg; CherryMX_1U
SW_N1: SW_Push_45deg; CherryMX_1U
SW_O1: SW_Push_45deg; CherryMX_1U
SW_P1: SW_Push_45deg; CherryMX_1U
SW_PLUS1: SW_Push_45deg; CherryMX_1U
SW_Q1: SW_Push_45deg; CherryMX_1U
SW_R1: SW_Push_45deg; CherryMX_1U
SW_RBRAC1: SW_Push_45deg; CherryMX_1U
SW_RET1: SW_Push_45deg; CherryMX_ISO_Enter
SW_RIGHT1: SW_Push_45deg; CherryMX_1U
SW_S1: SW_Push_45deg; CherryMX_1U
SW_SEL1: SW_Push_45deg; CherryMX_1.5U
SW_SFT1, SW_SFT2: SW_Push_45deg; CherryMX_2.5U
SW_SLASH1: SW_Push_45deg; CherryMX_1U
SW_SPC1: SW_Push_45deg; CherryMX_6U
SW_STOP1: SW_Push_45deg; CherryMX_1.5U
SW_T0, SW_T1, SW_T2, SW_T3, SW_T4, SW_T5, SW_T6, SW_T7, SW_T8, SW_T9, SW_T10: SW_Push_45deg; CherryMX_1U
SW_TAB1: SW_Push_45deg; CherryMX_1.5U
SW_TASTA1: SW_Push_45deg; CherryMX_1U
SW_TCOMMA1: SW_Push_45deg; CherryMX_1U
SW_TDOT1: SW_Push_45deg; CherryMX_1U
SW_TMINUS1: SW_Push_45deg; CherryMX_1U
SW_TPLUS1: SW_Push_45deg; CherryMX_1U
SW_TSLASH1: SW_Push_45deg; CherryMX_1U
SW_U1: SW_Push_45deg; CherryMX_1U
SW_UBAR1: SW_Push_45deg; CherryMX_1U
SW_UP1: SW_Push_45deg; CherryMX_1U
SW_V1: SW_Push_45deg; CherryMX_1U
SW_W1: SW_Push_45deg; CherryMX_1U
SW_X1: SW_Push_45deg; CherryMX_1U
SW_Y1: SW_Push_45deg; CherryMX_1U
SW_YEN1: SW_Push_45deg; CherryMX_1U
SW_Z1: SW_Push_45deg; CherryMX_1U
U1: 4515; SOP-24_7.5x15.4mm_P1.27mm

Connections:
/X0: J2.8, R8.2, SW_0.1, SW_8.1, SW_ASTA1.1, SW_C1.1, SW_F4.1, SW_K1.1, SW_S1.1, SW_SFT1.1, SW_SFT2.1, SW_SPC1.1, SW_T5.1, SW_TASTA1.1
/X1: J2.7, R7.2, SW_1.1, SW_9.1, SW_CLS1.1, SW_CTRL1.1, SW_D1.1, SW_F5.1, SW_L1.1, SW_RBRAC1.1, SW_T6.1, SW_T10.1, SW_TPLUS1.1
/X2: J2.6, R6.2, SW_2.1, SW_E1.1, SW_ESC1.1, SW_GRP1.1, SW_INS1.1, SW_LT1.1, SW_M1.1, SW_MINUS1.1, SW_T7.1, SW_TSLASH1.1, SW_U1.1
/X3: J2.5, R5.2, SW_3.1, SW_CAPS1.1, SW_DEL1.1, SW_F6.1, SW_GT1.1, SW_HAT1.1, SW_N1.1, SW_T0.1, SW_T8.1, SW_TAB1.1, SW_V1.1
/X4: J2.4, R4.2, SW_4.1, SW_G1.1, SW_KANA1.1, SW_LEFT1.1, SW_O1.1, SW_SLASH1.1, SW_STOP1.1, SW_T1.1, SW_T9.1, SW_W1.1, SW_YEN1.1
/X5: J2.3, R3.2, SW_5.1, SW_AT1.1, SW_BS1.1, SW_F1.1, SW_H1.1, SW_P1.1, SW_T2.1, SW_TMINUS1.1, SW_UBAR1.1, SW_UP1.1, SW_X1.1
/X6: J2.2, R2.2, SW_6.1, SW_A1.1, SW_DOWN1.1, SW_F2.1, SW_I1.1, SW_LBRAC1.1, SW_Q1.1, SW_SEL1.1, SW_T3.1, SW_TCOMMA1.1, SW_Y1.1
/X7: J2.1, R1.2, SW_7.1, SW_B1.1, SW_F3.1, SW_J1.1, SW_PLUS1.1, SW_R1.1, SW_RET1.1, SW_RIGHT1.1, SW_T4.1, SW_TDOT1.1, SW_Z1.1
/Y0: J1.1, U1.2 (A0)
/Y1: J1.2, U1.3 (A1)
/Y2: J1.3, U1.21 (A2)
/Y3: J1.4, U1.22 (A3)
GND: C1.2, J5.2, U1.12 (Vss), U1.23 (EN)
unnamed: D1.2 (A), SW_0.2, SW_1.2, SW_2.2, SW_3.2, SW_4.2, SW_5.2, SW_6.2, SW_7.2
unnamed: D1.1 (K), U1.11 (Q0)
unnamed: D2.2 (A), SW_8.2, SW_9.2, SW_AT1.2, SW_HAT1.2, SW_LBRAC1.2, SW_MINUS1.2, SW_PLUS1.2, SW_YEN1.2
unnamed: D2.1 (K), U1.9 (Q1)
unnamed: D3.2 (A), SW_A1.2, SW_ASTA1.2, SW_B1.2, SW_GT1.2, SW_LT1.2, SW_RBRAC1.2, SW_SLASH1.2, SW_UBAR1.2
unnamed: D3.1 (K), U1.10 (Q2)
unnamed: D4.2 (A), SW_C1.2, SW_D1.2, SW_E1.2, SW_F6.2, SW_G1.2, SW_H1.2, SW_I1.2, SW_J1.2
unnamed: D4.1 (K), U1.8 (Q3)
unnamed: D5.2 (A), SW_K1.2, SW_L1.2, SW_M1.2, SW_N1.2, SW_O1.2, SW_P1.2, SW_Q1.2, SW_R1.2
unnamed: D5.1 (K), U1.7 (Q4)
unnamed: D6.2 (A), SW_S1.2, SW_T10.2, SW_U1.2, SW_V1.2, SW_W1.2, SW_X1.2, SW_Y1.2, SW_Z1.2
unnamed: D6.1 (K), U1.6 (Q5)
unnamed: D7.2 (A), SW_CAPS1.2, SW_CTRL1.2, SW_F1.2, SW_F2.2, SW_F3.2, SW_GRP1.2, SW_KANA1.2, SW_SFT1.2, SW_SFT2.2
unnamed: D7.1 (K), U1.5 (Q6)
unnamed: D8.2 (A), SW_BS1.2, SW_ESC1.2, SW_F4.2, SW_F5.2, SW_RET1.2, SW_SEL1.2, SW_STOP1.2, SW_TAB1.2
unnamed: D8.1 (K), U1.4 (Q7)
unnamed: D9.2 (A), SW_CLS1.2, SW_DEL1.2, SW_DOWN1.2, SW_INS1.2, SW_LEFT1.2, SW_RIGHT1.2, SW_SPC1.2, SW_UP1.2
unnamed: D9.1 (K), U1.18 (Q8)
unnamed: D10.2 (A), SW_T0.2, SW_T1.2, SW_T2.2, SW_T3.2, SW_T4.2, SW_TASTA1.2, SW_TPLUS1.2, SW_TSLASH1.2
unnamed: D10.1 (K), U1.17 (Q9)
unnamed: D11.2 (A), SW_T5.2, SW_T6.2, SW_T7.2, SW_T8.2, SW_T9.2, SW_TCOMMA1.2, SW_TDOT1.2, SW_TMINUS1.2
unnamed: D11.1 (K), U1.20 (Q10)
unnamed: D12.2 (A), R10.2
unnamed: D12.1 (K), J3.1
unnamed: D13.2 (A), R9.2
unnamed: D13.1 (K), J4.1
VCC: C1.1, J5.1, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, U1.1 (EL), U1.24 (Vdd)

Notes on the sheet:
PPI PC0-3
PPI PB0-7
PSG IOB7
パスコン
PPI PC6

Board: 2 copper layers, 505.5 x 190.5 mm, 119 parts (0 on the bottom side), 40 nets.
